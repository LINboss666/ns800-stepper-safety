# Keil uVision project project.uvprojx, settings and files
target rt-thread (6240000::V6.24::ARMCLANG)
  device: NS800RT7P65D-DHQFBY2 Novosense
  pack: NOVOSENSE.NS800RT7XXX.0.5.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x00080000) IROM2(0x08080000,0x00080000) XRAM(0x20100000,0x00020000) XRAM2(0x20120000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYSCLK_USE_PLL, __CLK_TCK=RT_TICK_PER_SECOND, DUAL_CORE_ENABLE=0, USE_HAL_DRIVER, SYSCLK_SOURCE_USE_HXTL, __RTTHREAD__, NS800RT7P65X, __STDC_LIMIT_MACROS, RT_USING_LIBC, RT_USING_ARMLIBC, PLLCLK_SOURCE_USE_HXTL
  c misc: -Wno-tautological-constant-out-of-range-compare
  c include: packages\novosns-series-latest\NS800RT7XXX\Device\Inc;..\..\..\..\libcpu\arm\common;board;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;packages\novosns-series-latest\NS800RT7XXX\StdDriver\Inc\ti;..\libraries\HAL_Drivers\drivers\config;..\..\..\..\components\drivers\include;..\libraries\HAL_Drivers;board\port;..\..\..\..\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\ipc;applications;.;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\net\utest;packages\novosns-series-latest\NS800RT7XXX\StdDriver\Inc;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\components\finsh;..\..\..\..\components\drivers\spi;..\libraries\HAL_Drivers\drivers;packages\CMSIS-Core-latest\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8080000 size 0x80000
  memory RVCT6: RAM 0x20100000 size 0x20000
  memory RVCT7: RAM 0x20120000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: ns_flash.c ns_flash_shell.c ns_storage.c safety_gpio.c safety_state.c tmc2209.c step_pwm.c current_adc.c adxl345.c main.c
  group Board
    board/: board.c
  group CPU
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Device
    packages/novosns-series-latest/NS800RT7XXX/Device/Src/: system_NS800RT7xxx.c
    packages/novosns-series-latest/NS800RT7XXX/Device/Src/arm/: startup_NS800RT7xxx.s
  group DeviceDrivers
    ../../../../components/drivers/adc/: adc.c
    ../../../../components/drivers/can/: dev_can.c
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group HAL_Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_epwm.c drv_gpio.c drv_spi.c drv_uart.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group StdDriver
    packages/novosns-series-latest/NS800RT7XXX/StdDriver/Src/: adc.c aeshash.c anass.c awk.c bgcrc.c btim.c clb.c cmpss.c crc.c dac.c dcc.c debug.c dmamux.c ecap.c edma.c emath_basic.c emath_filter.c emath_matrix.c emath_transform.c epg.c epwm.c eqep.c exti.c flash.c flexcan.c fmu.c gpio.c i2c.c interrupt.c iwdg1.c iwdg2.c lin.c lptim.c mcm.c mu.c pmbus.c pwr.c qspi.c rcc.c sdfm.c sema.c smpu.c spi.c sram.c stim.c syscon.c tim.c trng.c uart.c upp.c version.c wwdg.c xbar.c
